DESCRIPTION = "${1:Some application}"
HOMEPAGE = "${2:http://foo.com}"
LICENSE = "${3:GPLv2}"
SECTION = "${4:base}"
DEPENDS = "${5}"
PR = "r0"

SRC_URI = "${6:http://some/path/to/foo.tar.gz}"
